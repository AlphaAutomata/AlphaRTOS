# Keil uVision project LaunchPadLMC.uvprojx, settings and files
target Controller (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LaunchPadLMC
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\driverlib;..\LaunchPad;.\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    src/: main.c
    ./src/: LMCterminal.c tasks.c scheduler.c
  group driverlib
    driverlib/: sysctl.c uart.c
    ./driverlib/: cpu.c interrupt.c gpio.c pwm.c systick.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1
